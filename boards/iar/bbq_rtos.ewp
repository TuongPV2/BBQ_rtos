# IAR project bbq_rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z64xxx4 Freescale MKL27Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL27Z64VLH4; FSL_RTOS_FREE_RTOS; FRDM_KL27Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM0; ../../rtos/freertos_8.2.3/Source/include; ../../CMSIS/Include; ../../devices; ../../devices/MKL27Z644/drivers; ..; ../../devices/MKL27Z644/utilities; ../../rtos/freertos_8.2.3/Source; ../..; ../../devices/MKL27Z644
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: freertos_i2c.out
  ILINK.IlinkIcfFile: MKL27Z64xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL27Z64VLH4; FSL_RTOS_FREE_RTOS; FRDM_KL27Z; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM0; ../../../../../rtos/freertos_8.2.3/Source/include; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MKL27Z644/drivers; ..; ../../../../../devices/MKL27Z644/utilities; ../../../../../rtos/freertos_8.2.3/Source; ../../..; ../../../../../devices/MKL27Z644
  ICCARM.CCOptLevel: 3
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../devices/MKL27Z644/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group drivers/freertos
    ../../devices/MKL27Z644/drivers/: fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h
  group freertos
    ../../rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../rtos/freertos_8.2.3/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_4.c
  group freertos/portable
    ../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group source
    ../: freertos_i2c.c FreeRTOSConfig.h
  group startup
    ../../devices/MKL27Z644/iar/: startup_MKL27Z644.s
    ../../devices/MKL27Z644/: system_MKL27Z644.c system_MKL27Z644.h
  group utilities
    ../../devices/MKL27Z644/utilities/: fsl_debug_console.c fsl_debug_console.h
